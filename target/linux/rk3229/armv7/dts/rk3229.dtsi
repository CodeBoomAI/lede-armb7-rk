/dts-v1/;
#include <dt-bindings/clock/rk3228-cru.h>
#include <dt-bindings/gpio/gpio.h>

/ {
    cpus {
        cpu@0 {
            device_type = "cpu";
            compatible = "arm,cortex-a9";
            reg = <0>;
        };
    };

    soc {
        #address-cells = <1>;
        #size-cells = <1>;
        compatible = "rockchip,rk3229";
        interrupt-controller@ffd11000 {
            compatible = "rockchip,rk3229-ic
